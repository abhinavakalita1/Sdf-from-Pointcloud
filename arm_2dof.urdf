Commit message: Added a lot of things

File: arm_2dof.urdf (robot description, URDF)
Before this commit: robot three_dof_arm, 3 links, 2 joints
Joints:
- joint joint1: origin xyz=0 0 0.10 rpy=0 0 0 -> xyz=0 0 0.50 rpy=0 0 0
- joint joint2: origin xyz=0 0 0.50 rpy=0 0 0 -> xyz=0 0 1.50 rpy=0 0 0
